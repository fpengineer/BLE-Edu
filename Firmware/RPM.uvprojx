# Keil uVision project RPM.uvprojx, settings and files
target nrf52832_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: .\User;.\User\HwAPI;.\User\HwTask;.\User\bleAPI;.\User\bleServices;.\nRF\components;.\nRF\components\ble\ble_advertising;.\nRF\components\ble\ble_dtm;.\nRF\components\ble\ble_racp;.\nRF\components\ble\ble_link_ctx_manager;.\nRF\components\ble\ble_services\ble_ancs_c;.\nRF\components\ble\ble_services\ble_ans_c;.\nRF\components\ble\ble_services\ble_bas;.\nRF\components\ble\ble_services\ble_bas_c;.\nRF\components\ble\ble_services\ble_cscs;.\nRF\components\ble\ble_services\ble_cts_c;.\nRF\components\ble\ble_services\ble_dfu;.\nRF\components\ble\ble_services\ble_dis;.\nRF\components\ble\ble_services\ble_gls;.\nRF\components\ble\ble_services\ble_hids;.\nRF\components\ble\ble_services\ble_hrs;.\nRF\components\ble\ble_services\ble_hrs_c;.\nRF\components\ble\ble_services\ble_hts;.\nRF\components\ble\ble_services\ble_ias;.\nRF\components\ble\ble_services\ble_ias_c;.\nRF\components\ble\ble_services\ble_lbs;.\nRF\components\ble\ble_services\ble_lbs_c;.\nRF\components\ble\ble_services\ble_lls;.\nRF\components\ble\ble_services\ble_nus;.\nRF\components\ble\ble_services\ble_nus_c;.\nRF\components\ble\ble_services\ble_rscs;.\nRF\components\ble\ble_services\ble_rscs_c;.\nRF\components\ble\ble_services\ble_tps;.\nRF\components\ble\common;.\nRF\components\ble\nrf_ble_gatt;.\nRF\components\ble\nrf_ble_qwr;.\nRF\components\ble\peer_manager;.\nRF\components\boards;.\nRF\components\libraries\atomic;.\nRF\components\libraries\atomic_fifo;.\nRF\components\libraries\atomic_flags;.\nRF\components\libraries\balloc;.\nRF\components\libraries\block_dev;.\nRF\components\libraries\block_dev\sdc;.\nRF\components\libraries\bootloader\ble_dfu;.\nRF\components\libraries\bsp;.\nRF\components\libraries\button;.\nRF\components\libraries\cli;.\nRF\components\libraries\cli\ble_uart;.\nRF\components\libraries\crc16;.\nRF\components\libraries\crc32;.\nRF\components\libraries\crypto;.\nRF\components\libraries\csense;.\nRF\components\libraries\csense_drv;.\nRF\components\libraries\delay;.\nRF\components\libraries\ecc;.\nRF\components\libraries\experimental_section_vars;.\nRF\components\libraries\experimental_task_manager;.\nRF\components\libraries\fds;.\nRF\components\libraries\fifo;.\nRF\components\libraries\fstorage;.\nRF\components\libraries\gfx;.\nRF\components\libraries\gpiote;.\nRF\components\libraries\hardfault;.\nRF\components\libraries\hardfault\nrf52;.\nRF\components\libraries\hci;.\nRF\components\libraries\led_softblink;.\nRF\components\libraries\log;.\nRF\components\libraries\log\src;.\nRF\components\libraries\low_power_pwm;.\nRF\components\libraries\mem_manager;.\nRF\components\libraries\memobj;.\nRF\components\libraries\mpu;.\nRF\components\libraries\mutex;.\nRF\components\libraries\pwm;.\nRF\components\libraries\pwr_mgmt;.\nRF\components\libraries\queue;.\nRF\components\libraries\ringbuf;.\nRF\components\libraries\scheduler;.\nRF\components\libraries\sdcard;.\nRF\components\libraries\sensorsim;.\nRF\components\libraries\slip;.\nRF\components\libraries\sortlist;.\nRF\components\libraries\spi_mngr;.\nRF\components\libraries\stack_guard;.\nRF\components\libraries\strerror;.\nRF\components\libraries\svc;.\nRF\components\libraries\timer;.\nRF\components\libraries\twi_mngr;.\nRF\components\libraries\twi_sensor;.\nRF\components\libraries\usbd;.\nRF\components\libraries\usbd\class\audio;.\nRF\components\libraries\usbd\class\cdc;.\nRF\components\libraries\usbd\class\cdc\acm;.\nRF\components\libraries\usbd\class\hid;.\nRF\components\libraries\usbd\class\hid\generic;.\nRF\components\libraries\usbd\class\hid\kbd;.\nRF\components\libraries\usbd\class\hid\mouse;.\nRF\components\libraries\usbd\class\msc;.\nRF\components\libraries\util;.\nRF\components\nfc\t4t_parser\hl_detection_procedure;.\nRF\components\nfc\t4t_parser\tlv;.\nRF\components\softdevice\common;.\nRF\components\softdevice\s132\headers;.\nRF\components\softdevice\s132\headers\nrf52;.\nRF\external\fatfs\port;.\nRF\external\fatfs\src;.\nRF\external\fatfs\src\option;.\nRF\external\fprintf;.\nRF\external\freertos\config;.\nRF\external\freertos\portable\ARM\nrf52;.\nRF\external\freertos\portable\CMSIS\nrf52;.\nRF\external\freertos\source\include;.\nRF\external\segger_rtt;.\nRF\external\utf_converter;.\nRF\integration\nrfx;.\nRF\integration\nrfx\legacy;.\nRF\modules\nrfx;.\nRF\modules\nrfx\drivers\include;.\nRF\modules\nrfx\hal;.\nRF\modules\nrfx\mdk
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200057b8 size 0xdde0
  link misc: --diag_suppress 6330
  group Application
    ./User/: main.c sdk_config.h
  group Board Definition
    ./nRF/components/boards/: boards.c
  group Board Support
    ./nRF/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group FreeRTOS
    ./nRF/external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./nRF/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
    ./nRF/external/freertos/source/portable/MemMang/: heap_1.c
    ./nRF/external/freertos/portable/ARM/nrf52/: port.c
  group UTF8/UTF16 converter
    ./nRF/external/utf_converter/: utf.c
  group FatFs
    ./nRF/external/fatfs/port/: diskio_blkdev.c
    ./nRF/external/fatfs/src/: ff.c
  group nRF_BLE
    ./nRF/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ./nRF/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ./nRF/components/ble/ble_advertising/: ble_advertising.c
    ./nRF/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ./nRF/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ./nRF/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_BLE_Services
    ./nRF/components/ble/ble_services/ble_bas/: ble_bas.c
    ./nRF/components/ble/ble_services/ble_dis/: ble_dis.c
    ./nRF/components/ble/ble_services/ble_hrs/: ble_hrs.c
    ./nRF/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ./nRF/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_ppi.c
    ./nRF/modules/nrfx/soc/: nrfx_atomic.c
    ./nRF/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_saadc.c nrfx_ppi.c nrfx_timer.c
    ./nRF/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ./nRF/components/libraries/button/: app_button.c
    ./nRF/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./nRF/components/libraries/timer/: app_timer_freertos.c
    ./nRF/components/libraries/crc16/: crc16.c
    ./nRF/components/libraries/fds/: fds.c
    ./nRF/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ./nRF/components/libraries/hardfault/: hardfault_implementation.c
    ./nRF/components/libraries/atomic_fifo/: nrf_atfifo.c
    ./nRF/components/libraries/atomic_flags/: nrf_atflags.c
    ./nRF/components/libraries/atomic/: nrf_atomic.c
    ./nRF/components/libraries/balloc/: nrf_balloc.c
    ./nRF/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./nRF/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ./nRF/components/libraries/memobj/: nrf_memobj.c
    ./nRF/components/libraries/ringbuf/: nrf_ringbuf.c
    ./nRF/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./nRF/components/libraries/strerror/: nrf_strerror.c
    ./nRF/components/libraries/sensorsim/: sensorsim.c
    ./nRF/components/libraries/uart/: app_uart_fifo.c
    ./nRF/components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ./nRF/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ./nRF/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ./nRF/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
  group HwAPI
    ./User/HwAPI/: HwAPI.h HwAPI Config.h HwAPI Def.h HwAPI_Boot.c HwAPI_LEDn.c HwAPI_Measure.c HwAPI_FileManager.c
  group HwTask
    ./User/HwTask/: TS_HwBoot.c TS_HwLED1.c TS_HwLED2.c TS_HwMeasure.c TS_HwFileManager.c
  group bleAPI
    ./User/bleAPI/: bleAPI.h bleAPI Config.h bleAPI Def.h
  group bleServices
    ./User/bleServices/: ble_cus.c ble_leds.c
target flash_s132_nrf52_6.1.1_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: as above
  output: s132_nrf52_6.1.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=1024 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
